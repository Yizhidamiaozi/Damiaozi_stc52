# Keil uVision project Findwaycar.uvproj, settings and files
target Findwaycar (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Findwaycar +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\inc
  group inc
    ../inc/: config.h STEENG.h findway.h motor.h
  group src
    ../src/: main.c STEENG.C findway.c motor.c
